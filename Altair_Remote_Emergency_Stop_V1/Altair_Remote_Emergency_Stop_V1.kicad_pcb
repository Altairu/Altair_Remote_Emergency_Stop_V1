# Repository Altairu/Altair_Remote_Emergency_Stop_V1

File README.md:

# Altair_Remote_Emergency_Stop_V1
Altair_Remote_Emergency_Stop_V1

## KiCad design Altair_Remote_Emergency_Stop_V1/Altair_Remote_Emergency_Stop_V1.kicad_pcb

Parts:
C1, C3, C5, C6, C7: 0.1u; C_0603_1608Metric
C2, C4: 47u; C_0603_1608Metric
C8, C9: 330u; CP_Elec_10x10
D1, D2: LED; LED_0603_1608Metric
D3, D4, D5: D; D_SOD-128
J1: USB_B; USB_B_Lumberg_2411_02_Horizontal
J2: XT60; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J3: XT60; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J4, J5: XT30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
Q1: Q_NMOS_GDS; TO-263-2
R1: 550; R_0603_1608Metric
R2, R3: 10K; R_0603_1608Metric
R4, R7: 1k; R_0603_1608Metric
R5: 100; R_0603_1608Metric
R6: 10; R_0603_1608Metric
SW1: RESET; SW_PUSH-12mm
SW2: BOOT; SW_PUSH-12mm
U1: esp32 c3; ESP32-C3-WROOM-02U
U2: LP2950-3.3_TO252; TO-252-2
U3: L7812; TO-252-2
U4: TLP152; MFSOP6-5_4.4x3.6mm_P1.27mm
U5: ヒューズ; XS-506A

Connections:
+1: J2.2, J5.2, U5.2
+3.3V: C3.1, D5.2 (A), R1.1, R2.1, R3.1, U1.1 (+3.3V), U2.3 (VO)
+5V: C1.1, C2.1, D5.1 (K), J1.1 (VBUS), U2.1 (VI)
+12V: C6.1, C7.1, D4.2 (A), R4.1, U3.3 (OUT), U4.6
+24V: C4.1, C5.1, C8.1, C9.1, D4.1 (K), J3.2, J4.2, U3.1 (IN), U5.1
-1: D3.1 (K), J2.1, J5.1, Q1.2 (D)
GND: C1.2, C2.2, C3.2, D1.1 (K), J1.4 (GND), J1.5 (Shield), SW1.1, SW2.2, U1.9 (GND), U1.19 (GND), U2.2 (GND), U4.3
GND1: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D2.1 (K), D3.2 (A), J3.1, J4.1, Q1.3 (S), R7.1, U3.2 (GND), U4.4
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R4.2
unnamed: Q1.1 (G), R6.2
unnamed: R5.2, U4.1
unnamed: R6.1, R7.2, U4.5
unnamed: R2.2, SW1.2, U1.2 (EN/CHIP_PU)
unnamed: R3.2, SW2.1, U1.8 (GPIO9)
Ps1: R5.1, U1.3 (GPIO4/ADC1_CH4), U1.4 (GPIO5/ADC2_CH0), U1.15 (GPIO3/ADC1_CH3), U1.16 (GPIO2/ADC1_CH2)
USB+: J1.3 (D+), U1.14 (GPIO19/USB_D+)
USB-: J1.2 (D-), U1.13 (GPIO18/USB_D-)

Notes on the sheet:
降圧回路
電源駆動部
マイコン回路

Board: 2 copper layers, 99.1 x 50.2 mm, 34 parts (0 on the bottom side), 18 nets.
